// /**
//  * @file    ctrl_position.c
//  * @brief   位置环PID控制实现
//  */

#include "ctrl_position.h"
#include "pid_common.h"

extern Axis_t g_axis;

extern System_t mySystem;

void Ctrl_Pos_Init(void)
{
    // 调度所有轴 的 位置环 初始化
    for (int i = 0; i < MAX_AXIS_NUM; i++) {

        PID_Init(&mySystem.axis[i].pos_param,
                &mySystem.axis[i].pos_ctrl);

        mySystem.axis[i].pos_param.alg_type = PID_ALG_INCREMENT;
        mySystem.axis[i].pos_param.kp = 900;
        mySystem.axis[i].pos_param.ki = 0;
        mySystem.axis[i].pos_param.kd = 0;
        mySystem.axis[i].pos_param.integral_max = 0;

        // 位置环参数、限幅初始化
        // 位置环的输出为 目标速度 == 速度环的输入
        mySystem.axis[i].pos_ctrl.out_max = 1500.0f;
        mySystem.axis[i].pos_ctrl.out_min = -1500.0f;

        // 位置偏差阈值
        mySystem.axis[i].pos_ctrl.stall_thr = 0.5;      // 0.5mm
    }
}

//  注册管理平台 调度运行 运行时间 约10ms级
void Ctrl_Pos_Task(void)
{
    // 调度所有轴 的 位置环算法 
    for (int i = 0; i < MAX_AXIS_NUM; i++) {

        // if (mySystem.axis[i].enable && mySystem.axis[i].motor.enable)
        if (mySystem.axis[i].pos_ctrl.enable)
        {
            PID_Calc(&mySystem.axis[i].pos_param,
                    &mySystem.axis[i].pos_ctrl,
                    mySystem.axis[i].pos_ctrl.set,
                    mySystem.axis[i].pos_ctrl.fdb);

            // if (mySystem.axis[i].pos_ctrl.out < 0 && mySystem.axis[i].motor.dir == MOT_DIR_REVERSE)
            // {
            //     mySystem.axis[i].pos_ctrl.out *= -1;
            // }

            // 输出 -> 速度环目标
            // mySystem.axis[i].spd_ctrl.set = mySystem.axis[i].pos_ctrl.out;
            // mySystem.axis[i].curr_ctrl.set = mySystem.axis[i].pos_ctrl.out * mySystem.axis[i].pos_ctrl.out_nor;
        }
    }
}

// // 模块注册
// static const SysModule_t CtrlPos_Module = {
//     .name = "Ctrl_Pos",
//     .prio = 5,
//     .period_ms = 5,
//     .enabled = 1,
//     .init = Ctrl_Pos_Init,
//     .task = Ctrl_Pos_Task,
// };

// void Ctrl_Pos_Register(void)
// {
//     Sys_Scheduler_RegisterModule(&CtrlPos_Module);
// }

