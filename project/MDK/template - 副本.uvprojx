# Keil uVision project template - 副本.uvprojx, settings and files
target template_Debug (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: HC32F460JETA HDSC
  pack: HDSC.HC32F46x.1.0.6
  cpu: IRAM(0x1FFF8000,0x2F000) IRAM2(0x200F0000,0x1000) IROM(0x00000000,0x80000) IROM2(0x03000C00,0x003FC) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: template +hex
  AfterMake: fromelf.exe --bin --output ".\output\debug\@L.bin" ".\output\debug\@L.axf"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __DEBUG,HC32F460,USE_DDL_DRIVER,
  c include: ..\app\can;..\app\config;..\app\key;..\app\led;..\app\loop;..\app\motor;..\app\pid;..\app\pos;..\app\position_sensor;..\app\power;..\app\pwm;..\app\state;..\app\storage;..\core;..\config;..\service\RTT;..\app;..\drivers\hc32_ll_driver\inc;..\drivers\cmsis\Device\HDSC\hc32f4xx\Include;..\drivers\cmsis\Include;..\service;..\drivers\hal;..\core;..\app\storage\flash-mcu;..\app\storage\flash-spi;..\startup;..\drivers\drv;..\app\can\uds
  library: MicroLIB
  memory RVCT4: ROM 0x1a000 size 0x32000
  memory RVCT5: ROM 0x3000c00 size 0x3fc
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  link misc: --keep=*Handler
  group app
    ../app/can/: app_can.c can_hw.c can_module.c
    ../app/config/: work_config.c work_config_table.c
    ../app/key/: key.c key_hw_table.c key_module.c
    ../app/led/: led.c led_hw_table.c led_module.c
    ../app/loop/: ctrl_current.c ctrl_position.c ctrl_speed.c
    ../app/motor/: motor_hw_table.c motor_module.c
    ../app/pid/: pid_common.c
    ../app/pos/: app_pos.c pos_hw.c pos_module.c
    ../app/position_sensor/: position_sensor.c sensor_pot.c
    ../app/power/: app_power.c power_hw.c power_manager.c power_module.c
    ../app/pwm/: app_pwm.c pwm_hw.c pwm_module.c
    ../app/state/: act_state.c can_state.c mot_state.c mot_state_hw_table.c state_engine.c sys_state.c
    ../app/storage/: data_storage.c storage.c
    ../app/storage/flash-mcu/: flash_mcu.c
    ../app/: system.c
  group config
    ../config/: loop_config.c
  group core
    ../core/: event_engine.c event_group.c msg_pubsub.c ring_buffer.c software_timer.c sys_init.c sys_sched.c
  group drivers
    ../drivers/cmsis/Device/HDSC/hc32f4xx/Source/: system_hc32f460.c
    ../drivers/drv/: drv_mcu_flash.c
    ../drivers/hal/: hal_adc.c hal_gpio.c hal_pwm.c hal_timer.c
    ../drivers/hc32_ll_driver/src/: hc32_ll.c hc32_ll_adc.c hc32_ll_aes.c hc32_ll_aos.c hc32_ll_can.c hc32_ll_clk.c hc32_ll_cmp.c hc32_ll_crc.c hc32_ll_dbgc.c hc32_ll_dcu.c hc32_ll_dma.c hc32_ll_efm.c hc32_ll_emb.c hc32_ll_event_port.c hc32_ll_fcg.c hc32_ll_fcm.c hc32_ll_gpio.c hc32_ll_hash.c hc32_ll_i2c.c hc32_ll_i2s.c hc32_ll_icg.c hc32_ll_interrupts.c hc32_ll_keyscan.c hc32_ll_mpu.c hc32_ll_ots.c hc32_ll_pwc.c hc32_ll_qspi.c hc32_ll_rmu.c hc32_ll_rtc.c hc32_ll_sdioc.c hc32_ll_spi.c hc32_ll_sram.c hc32_ll_swdt.c hc32_ll_tmr0.c hc32_ll_tmr4.c hc32_ll_tmr6.c hc32_ll_tmra.c hc32_ll_trng.c hc32_ll_usart.c hc32_ll_usb.c hc32_ll_utility.c hc32_ll_wdt.c hc32f460_ll_interrupts_share.c
  group service
    ../service/: config_manager.c fault_manager.c hw_tim_driver.c log_rtt.c soft_timer.c sys_tick.c
  group RTT
    ../service/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group startup
    ../startup/: main.c
    ./: startup_hc32f460.s
  group test
    ../test/: test_config.c test_hal.c test_log.c test_main.c test_msg.c test_power.c test_sched.c test_storage.c test_event.c
  group uds
    ../app/can/uds/: adapter_can.c bootloader_app.c flash_download.c isotp_transport.c security_access.c uds_diagnostic.c uds_dl_bridge.c uds_ota.c uds_rx_entry.c
target template_Release (5060020::V5.06 (build 20)::ARMCC)
  device: HC32F460PETB HDSC
  pack: HDSC.HC32F46x.1.0.6
  cpu: IROM1(0x00000000,0x80000) IROM2(0x03000C00,0x3FC) IRAM1(0x1FFF8000,0x2F000) IRAM2(0x200F0000,0x1000) CPUTYPE("Cortex-M4") FPU2 CLOCK(8000000) ESEL ELITTLE
  output: template +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: HC32F460,USE_DDL_DRIVER,
  c include: ..\source;../../../../drivers/cmsis/Device/HDSC/hc32f4xx/Include;../../../../drivers/cmsis/Include;../../../../drivers/hc32_ll_driver/inc;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x3000c00 size 0x3c0
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  scatter file: .\config\linker\HC32F460xE.sct
  link misc: --keep=*Handler
