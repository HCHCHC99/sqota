#include "flash_mcu.h"
#include "drv_mcu_flash.h"
#include <string.h>

#define ANGLE_MAGIC    0x5AA55AA5UL
/* 存储区大小 私有数据结构体 */
#define ANGLE_BLK_SIZE sizeof(priv_data_t)

/* ==================== 私有方法声明( priv_ops) ==================== */
static int32_t storage_load(storage_t *self);
static int32_t storage_save(storage_t *self);

/* ==================== 公开方法声明( storage_ops_t) ==================== */
static int32_t storage_init(storage_t *self);
static int32_t storage_write_model(storage_t *self, int32_t model);
static int32_t storage_read_model(storage_t *self);
static int32_t storage_write_vn(storage_t *self, uint16_t vn);
static uint16_t storage_read_vn(storage_t *self);
static int32_t storage_write_dir(storage_t *self, uint16_t dir);
static uint16_t storage_read_dir(storage_t *self);
static int32_t storage_write_calib(storage_t *self, axis_num_t index, uint32_t flag);
static uint32_t storage_read_calib(storage_t *self, axis_num_t index);
static int32_t storage_write_pos(storage_t *self, axis_num_t index, uint32_t pos);
static uint32_t storage_read_pos(storage_t *self, axis_num_t index);
static priv_data_t storage_read_all(storage_t *self);

/* ==================== 函数指针结构体绑定 ==================== */
static storage_ops_t storage_ops =
{
    .init           = storage_init,
    .write_model    = storage_write_model,
    .read_model     = storage_read_model,

    .write_vn       = storage_write_vn,
    .read_vn        = storage_read_vn,

    .write_dir      = storage_write_dir,
    .read_dir       = storage_read_dir,

    .write_calib    = storage_write_calib,
    .read_calib     = storage_read_calib,

    .write_pos      = storage_write_pos,
    .read_pos       = storage_read_pos,

    .read_all       = storage_read_all,
};

static storage_priv_ops_t storage_priv_ops =
{
    .load = storage_load,
    .save = storage_save,
};

/* ==================== 全局单例实例 ==================== */
storage_t storage_dev =
{
    .data = {0},
    .ops = &storage_ops,
    .priv_ops = &storage_priv_ops,
};

/* ==================== 对外公有接口实现 ==================== */
static int32_t storage_init(storage_t *self)
{
    flash_store.ops->init(&flash_store, ANGLE_BLK_SIZE);
    return self->priv_ops->load(self);
}

/* 写入机型参数 */
static int32_t storage_write_model(storage_t *self, int32_t model)
{
    self->data.model = model;
    return self->priv_ops->save(self);
}

/* 读取机型参数 */
static int32_t storage_read_model(storage_t *self)
{
    return (int32_t)self->data.model;
}

/* 写入 软件版本 参数 */
static int32_t storage_write_vn(storage_t *self, uint16_t vn)
{
    self->data.soft_vn = vn;
    return self->priv_ops->save(self);
}

/* 读取 软件版本 参数 */
static uint16_t storage_read_vn(storage_t *self)
{
    return (uint16_t)self->data.soft_vn;
}

/* 写入 运动方向逻辑 参数 */
static int32_t storage_write_dir(storage_t *self, uint16_t dir)
{
    self->data.moving_dir = dir;
    return self->priv_ops->save(self);
}

/* 读取 运动方向逻辑 参数 */
static uint16_t storage_read_dir(storage_t *self)
{
    return (uint16_t)self->data.moving_dir;
}

/* 按轴号写入标定标志，多轴数组存取 */
static int32_t storage_write_calib(storage_t *self, axis_num_t index, uint32_t flag)
{
    /* 简单越界防护 */
    if(index >= AXIS_NUM_MAX)
    {
        return -1;
    }
    self->data.axis_data[index].calib_flag = flag;
    return self->priv_ops->save(self);
}

/* 按轴号写入标定位置，系统只会标定 分离位置，自动计算出结合位置 */
static int32_t storage_write_pos(storage_t *self, axis_num_t index, uint32_t pos)
{
    /* 简单越界防护 */
    if(index >= AXIS_NUM_MAX)
    {
        return -1;
    }
    // memcpy( &(self->data.axis_data[index]),&data,sizeof(&(self->data.axis_data[index])));
    self->data.axis_data[index].position_separae = pos;

    if (self->data.moving_dir == 0 )  // 结合方向为 推杆伸出，分离方向为 推杆缩回
    {
        self->data.axis_data[index].position_combine = self->data.axis_data[index].position_separae + 22*0.03;  // 每 mm 对应30mV
    }else if (self->data.moving_dir == 1) // 结合方向为 推杆缩回，分离方向为 推杆伸出
    {
        self->data.axis_data[index].position_combine = self->data.axis_data[index].position_separae - 22*0.03;  // 每 mm 对应30mV
    }

    return self->priv_ops->save(self);
}


/* 按轴号读取标定标志 */
static uint32_t storage_read_calib(storage_t *self, axis_num_t index)
{
    if(index >= AXIS_NUM_MAX)
    {
        return 0U;
    }
    return self->data.axis_data[index].calib_flag;
}

/* 按轴号读取标定位置-分离位置 */
static uint32_t storage_read_pos(storage_t *self, axis_num_t index)
{
    if(index >= AXIS_NUM_MAX)
    {
        return 0;
    }
    return self->data.axis_data[index].position_separae;
}

/* 读取所有数据 */
static priv_data_t storage_read_all(storage_t *self)
{
    return self->data;
}
/* ==================== 底层私有加载/保存 ==================== */
static int32_t storage_load(storage_t *self)
{
    flash_store.ops->read(&flash_store, flash_store.ops->get_last_addr(&flash_store),
                          (uint8_t*)&self->data, ANGLE_BLK_SIZE);
    if (self->data.magic != ANGLE_MAGIC)
    {
        /* magic非法，初始化全量默认值 */
        self->data.magic  = ANGLE_MAGIC;
        self->data.model  = 0U;
        memset(self->data.axis_data, 0, sizeof(self->data.axis_data));
        storage_save(self);
    }
    return 0;
}

static int32_t storage_save(storage_t *self)
{
    uint8_t last_data[ANGLE_BLK_SIZE];
    flash_store.ops->read(&flash_store, flash_store.ops->get_last_addr(&flash_store),
                          last_data, ANGLE_BLK_SIZE);
    /* 数据无变化直接返回，不写Flash */
    if (memcmp(&self->data, last_data, ANGLE_BLK_SIZE) == 0)
    {
        return 0;
    }
    self->data.magic = ANGLE_MAGIC;
    uint32_t addr = flash_store.ops->get_next_addr(&flash_store);
    flash_store.ops->write(&flash_store, addr, (uint8_t*)&self->data, ANGLE_BLK_SIZE);
    flash_store.priv.last_valid_addr = addr;
    flash_store.priv.next_write_addr = addr + ANGLE_BLK_SIZE;
    return 0;
}

/* ==================== 对外公有接口实现 ==================== */
void bsp_storeage_init(void){
    storage_dev.ops->init(&storage_dev);
}
void bsp_write_model( uint32_t model){
    storage_dev.ops->write_model(&storage_dev, model);
}
uint32_t bsp_read_model(void){
    return storage_dev.ops->read_model(&storage_dev);
}
void bsp_write_cali(axis_num_t index ,uint32_t flag){
    storage_dev.ops->write_calib(&storage_dev, index,flag);
}
uint32_t bsp_read_cali(axis_num_t index){
    return storage_dev.ops->read_calib(&storage_dev,index);
}

uint32_t bsp_read_pos(axis_num_t index){
    return storage_dev.ops->read_calib(&storage_dev,index);
}

priv_data_t bsp_read_all(void){
    return storage_dev.ops->read_all(&storage_dev);
}



#if 0
/* ==================== 测试接口 ==================== */
void bsp_storage_test(void)
{
   // 初始化
   storage_dev.ops->init(&storage_dev);

   // 单独读写 机型
   storage_dev.ops->write_model(&storage_dev, 12345);
   int32_t ang = storage_dev.ops->read_model(&storage_dev);

   // 单独读写 机型
   storage_dev.ops->write_model(&storage_dev, 12345);
    ang = storage_dev.ops->read_model(&storage_dev);

   // 单独读写 机型
   storage_dev.ops->write_model(&storage_dev, 12346);
    ang = storage_dev.ops->read_model(&storage_dev);

    // 单独读写 机型
    storage_dev.ops->write_model(&storage_dev, 12347);
     ang = storage_dev.ops->read_model(&storage_dev);

    // 单独读写 机型
    storage_dev.ops->write_model(&storage_dev, 12348);
     ang = storage_dev.ops->read_model(&storage_dev);

   // 单独读写校准标记
   storage_dev.ops->write_calib(&storage_dev, 0,1);
   uint32_t flag = storage_dev.ops->read_calib(&storage_dev,0);

   storage_dev.ops->write_calib(&storage_dev, 0,1);
   flag = storage_dev.ops->read_calib(&storage_dev,0);

   storage_dev.ops->write_calib(&storage_dev, 0,1);
   flag = storage_dev.ops->read_calib(&storage_dev,0);

   storage_dev.ops->write_calib(&storage_dev, 1,1);
   flag = storage_dev.ops->read_calib(&storage_dev,1);

   storage_dev.ops->write_calib(&storage_dev, 1,1);
   flag = storage_dev.ops->read_calib(&storage_dev,1);

   storage_dev.ops->write_calib(&storage_dev, 1,1);
   flag = storage_dev.ops->read_calib(&storage_dev,1);
}
#endif



