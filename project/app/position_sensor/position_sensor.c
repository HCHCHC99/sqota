/**
 * @file position_sensor.c
 * @brief 位置传感器管理模块（多传感器注册、调度、分发）
 */

#include "position_sensor.h"
#include "log_rtt.h"
#include "msg_pubsub.h"
#include "msg_topics.h"

#include <stddef.h> 

#if SYS_ENABLE_POS_SENSOR

/* 自动包含已使能的传感器驱动 */
#if SYS_ENABLE_SENSOR_POT
#include "sensor_pot.h"
#endif

#if SYS_ENABLE_SENSOR_HALL
#include "sensor_hall.h"
#endif

#if SYS_ENABLE_SENSOR_INC_ENC
#include "sensor_inc_enc.h"
#endif

#if SYS_ENABLE_SENSOR_ABS_ENC
#include "sensor_abs_enc.h"
#endif

/*==============================
 *  可裁剪传感器自动注册表
 *==============================*/
static const PosSensorRegister_t s_sensor_list[] = {
#if SYS_ENABLE_SENSOR_POT
    { POS_SENSOR_POT,      &PotOps,          "Potentiometer" },
#endif

#if SYS_ENABLE_SENSOR_HALL
    { POS_SENSOR_HALL,     &HallOps,         "Hall_Sensor" },
#endif

#if SYS_ENABLE_SENSOR_INC_ENC
    { POS_SENSOR_INC_ENC,  &IncEncOps,       "Incremental_Encoder" },
#endif

#if SYS_ENABLE_SENSOR_ABS_ENC
    { POS_SENSOR_ABS_ENC,  &AbsEncOps,       "Absolute_Encoder" },
#endif
};

#define SENSOR_COUNT             (sizeof(s_sensor_list) / sizeof(PosSensorRegister_t))

/*==============================
 *  自动选择当前使能的传感器
 *==============================*/
#if SYS_ENABLE_SENSOR_POT
#define CURRENT_SENSOR           POS_SENSOR_POT
#elif SYS_ENABLE_SENSOR_HALL
#define CURRENT_SENSOR           POS_SENSOR_HALL
#elif SYS_ENABLE_SENSOR_INC_ENC
#define CURRENT_SENSOR           POS_SENSOR_INC_ENC
#elif SYS_ENABLE_SENSOR_ABS_ENC
#define CURRENT_SENSOR           POS_SENSOR_ABS_ENC
#else
#define CURRENT_SENSOR           POS_SENSOR_NONE
#endif

/*==============================
 *  内部全局变量
 *==============================*/
static const PosSensorOps_t *s_cur_ops = NULL;
static PosData_t s_pos_data = {0};

/*==============================
 *  内部函数
 *==============================*/
static uint8_t PosSensor_Select(PosSensorType_t type);

/**
 * @brief 初始化传感器模块
 */
void PosSensor_Init(void)
{
    if (CURRENT_SENSOR == POS_SENSOR_NONE) {
        LOG_ERROR("PosSensor: disabled");
        return;
    }

    if (PosSensor_Select(CURRENT_SENSOR) == 0) {
        if (s_cur_ops != NULL && s_cur_ops->init != NULL) {
            s_cur_ops->init();
        }
//        LOG_INFO("PosSensor: 已加载传感器 -> %s", s_cur_ops->name);
    } else {
        LOG_ERROR("PosSensor: Sensor Selection Failed");
    }
}

/**
 * @brief 周期调度任务
 */
void PosSensor_Task(void)
{
    if (s_cur_ops == NULL) return;

    s_pos_data.raw     = s_cur_ops->read_raw();
    s_pos_data.mm      = s_cur_ops->read_mm();
    s_pos_data.percent = s_cur_ops->read_percent();
    s_pos_data.valid   = 1;

    /* 发布位置数据 */
    Msg_Publish(TOPIC_POS_UPDATED, &s_pos_data, sizeof(PosData_t), MSG_PRIO_HIGH);
}

/**
 * @brief 获取当前位置数据
 */
const PosData_t* PosSensor_GetData(void)
{
    return &s_pos_data;
}

/**
 * @brief 根据类型选择传感器
 */
static uint8_t PosSensor_Select(PosSensorType_t type)
{
    for (uint8_t i = 0; i < SENSOR_COUNT; i++) {
        if (s_sensor_list[i].type == type) {
            s_cur_ops = s_sensor_list[i].ops;
            return 0;
        }
    }
    return 1;
}

#endif /* SYS_ENABLE_POS_SENSOR */


